# Keil uVision project EXTI.uvprojx, settings and files
target EXTI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EXTI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\project;..\..\lib\CMSIS\CM3\CoreSupport;..\..\lib\STM32F10x_StdPeriph_Driver\inc;..\..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\HC595;..\SystemTick;..\USART;..\TIMER;..\EXTI;..\GPIO;..\CLOCK;..\FLASH;..\RING_BUFFER;..\WATCH_DOG;..\ADC;..\SPI;..\SX1278
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_i2c.c
    ../../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group user
    ../: main.c stm32f10x_it.c system_stm32f10x.c main.h
  group HC595
    ../HC595/: HC595.h HC595.c
  group SystemTick
    ../SystemTick/: SystemTick.c SystemTick.h
  group USART
    ../USART/: USART.c USART.h
  group TIMER
    ../TIMER/: TIMER.c TIMER.h
  group EXTI
    ../EXTI/: EXTI.c EXTI.h
  group GPIO
    ../GPIO/: GPIO.c GPIO.h
  group CLOCK
    ../CLOCK/: CLOCK.c CLOCK.h
  group FLASH
    ../FLASH/: FLASH.c FLASH.h
  group RING_BUFFER
    ../RING_BUFFER/: RING_BUFFER.c RING_BUFFER.h
  group WATCH_DOG
    ../WATCH_DOG/: WATCH_DOG.c WATCH_DOG.h
  group ADC
    ../ADC/: ADC.c ADC.h
  group SPI
    ../SPI/: SPI.c SPI.h
  group SX1278
    ../SX1278/: sx1278.c sx1278.h
  group DS1307
    ../DS1307/: DS1307.c DS1307.h
